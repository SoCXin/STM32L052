# Keil uVision project RFID.uvprojx, settings and files
target Qitas (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L052K6Tx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.0.1
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: RFID_STM32L052K6 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L052xx
  c include: ..\Libraries\CMSIS\Include;..\Libraries\CMSIS\Device\ST\STM32L0xx\Include;..\Libraries\STM32L0xx_HAL_Driver\Inc;..\User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group USER
    ../User/: main.c stm32l0xx_hal_msp.c stm32l0xx_it.c
    ../User/cc1101/: cc1101.c
    ../User/spi/: bsp_spi.c
    ../User/usart/: bsp_debug_usart.c
    ../User/function/: function.c
    ../User/adxl362/: adxl362.c
    ../User/wwdg/: bsp_wwdg.c
    ../User/pvd/: bsp_pvd.c
  group CMSIS
    ../Libraries/CMSIS/Device/ST/STM32L0xx/Source/Templates/: system_stm32l0xx.c
  group STARTUP
    ../Libraries/CMSIS/Device/ST/STM32L0xx/Source/Templates/arm/: startup_stm32l052xx.s
  group STM32L0xx_HAL_Driver
    ../Libraries/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_cortex.c stm32l0xx_hal_dma.c stm32l0xx_hal_gpio.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_spi.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_usart.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_wwdg.c
